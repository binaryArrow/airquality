<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild/>
  <project>
    <path>$WS_DIR$\Atmega2564rfr2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Atmega256rfr2.ewp</path>
  </project>
</workspace>
