# IAR project Atmega2564rfr2_OTA.ewp, settings and files
configuration All_StdlinkSec_MegaRf_Atmega2564rfr2_8Mhz (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m2564rfr2 ATmega2564RFR2
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_8MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ALL
  ICCAVR.CCDiagSuppress: Pa050, Pe188
  ICCAVR.newCCIncludePaths: ..; ../include; ../../../BitCloud/Components/BSP/MEGARF/include; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/std/include; ../../../BitCloud/Components/PersistDataServer/wl/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Types/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Util/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Timer/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Task/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_ErrH/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Log/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Memory/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Init/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/src; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/USBFIFO/include; ../../../BitCloud/Components/HAL/avr/atmega128rfa1/common/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/OFD/include; ../../../BitCloud/Components/HAL/drivers/ISD/include; ../../../BitCloud/Components/ZCL/include/private; ../../../BitCloud/Components/ZCL/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/MAC_HWD/include
  ICCAVR.PreInclude: MakerulesBc_All_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.h
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_All_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_8Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
configuration Coordinator_StdlinkSec_MegaRf_Atmega2564rfr2_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_8MHz; STDLINK_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCAVR.PreInclude: MakerulesBc_Coordinator_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_Coordinator_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_8Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
configuration Router_StdlinkSec_MegaRf_Atmega2564rfr2_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_8MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCAVR.PreInclude: MakerulesBc_Router_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_Router_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_8Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
configuration EndDevice_StdlinkSec_MegaRf_Atmega2564rfr2_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_8MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCAVR.PreInclude: MakerulesBc_EndDevice_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_EndDevice_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_8Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
configuration All_MegaRf_Atmega2564rfr2_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_8MHz; NO_SECURITY_MODE; STACK_TYPE_ALL
  ICCAVR.PreInclude: MakerulesBc_All_Atmega2564rfr2_Atmega2564rfr2_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_All_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_8Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
configuration All_Sec_MegaRf_Atmega2564rfr2_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_8MHz; STANDARD_SECURITY_MODE; STACK_TYPE_ALL
  ICCAVR.PreInclude: MakerulesBc_All_Sec_Atmega2564rfr2_Atmega2564rfr2_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_All_Sec_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_8Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
configuration All_StdlinkSec_MegaRf_Atmega2564rfr2_16Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_16MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ALL
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_All_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_16Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
configuration Coordinator_StdlinkSec_MegaRf_Atmega2564rfr2_16Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_16MHz; STDLINK_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCAVR.PreInclude: as above
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_Coordinator_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_16Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
configuration Router_StdlinkSec_MegaRf_Atmega2564rfr2_16Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_16MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCAVR.PreInclude: as above
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_Router_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_16Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
configuration EndDevice_StdlinkSec_MegaRf_Atmega2564rfr2_16Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_16MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCAVR.PreInclude: as above
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_EndDevice_StdlinkSec_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_16Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
configuration All_MegaRf_Atmega2564rfr2_16Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_16MHz; NO_SECURITY_MODE; STACK_TYPE_ALL
  ICCAVR.PreInclude: MakerulesBc_All_Atmega2564rfr2_Atmega2564rfr2_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_All_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_16Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
configuration All_Sec_MegaRf_Atmega2564rfr2_16Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA2564RFR2; HAL_16MHz; STANDARD_SECURITY_MODE; STACK_TYPE_ALL
  ICCAVR.PreInclude: MakerulesBc_All_Sec_Atmega2564rfr2_Atmega2564rfr2_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_All_Sec_Atmega2564rfr2_Atmega2564rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega2564rfr2_16Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega2564rfr2_Iar.o
  group src
    ../src/: WSNCommandHandler.c WSNSensorManager.c WSNEndDevice.c WSNZclManager.c WSNCoord.c WSNMessageSender.c WSNVisualizer.c WSNRouter.c WSNDemoApp.c WSNUARTManager.c
  group include
    ../include/: WSNZclManager.h WSNVisualizer.h WSNUARTManager.h WSNMessageSender.h WSNCoord.h WSNDemoApp.h WSNEndDevice.h WSNRouter.h WSNCommandHandler.h WSNSensorManager.h WSNCommand.h serialInterface.h
  group Components/PersistDataServer/std/src
    ../../../BitCloud/Components/PersistDataServer/std/src/: stdPdsMemAccess.c stdPdsTimer.c stdPdsMem.c stdPdsWriteData.c stdPdsCrcService.c stdPdsInit.c stdPdsEvents.c stdPdsDataServer.c
  group Components/PersistDataServer/std/include
    ../../../BitCloud/Components/PersistDataServer/std/include/: stdPdsDbg.h stdPdsFiles.h stdPdsWriteData.h stdPdsTimer.h stdPdsMemAccess.h stdPdsMemAbstract.h stdPdsCrcService.h stdPdsMem.h stdPdsMemIds.h
  group Components/PersistDataServer/src
    ../../../BitCloud/Components/PersistDataServer/src/: fakePds.c
  group Components/PersistDataServer/include
    ../../../BitCloud/Components/PersistDataServer/include/: pdsDataServer.h pdsMemIds.h
  group Components/PersistDataServer/wl/src
    ../../../BitCloud/Components/PersistDataServer/wl/src/: wlPdsTypesConverter.c wlPdsTaskManager.c wlPdsSecurity.c wlPdsInit.c wlPdsDataServer.c
  group Components/PersistDataServer/wl/nv_components/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/src/: S_Nv-SamR21.c S_Nv-ATmega.c S_Nv-External.c S_Nv_Stub.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src/: S_XNv.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/src/: D_Nv.c
  group Components/PersistDataServer/wl/nv_components/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include/: S_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include/: D_XNv_Init.h D_XNv_Bindings.h D_XNv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include/: D_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include/: S_XNv_Bindings.h
  group Components/PersistDataServer/wl/include
    ../../../BitCloud/Components/PersistDataServer/wl/include/: wlPdsBindings.h wlPdsSecurity.h wlPdsMemIds.h wlPdsTypesConverter.h wlPdsTaskManager.h wlPdsTypes.h
  group Components/SystemEnvironment/src
    ../../../BitCloud/Components/SystemEnvironment/src/: sysIdleHandler.c sysSleep.c sysStat.c sysEventsHandler.c sysQueue.c sysUtils.c sysAssert.c sysDuplicateTable.c sysInit.c sysTaskManager.c dbg.c sysMutex.c sysTimer.c
  group Components/SystemEnvironment/include
    ../../../BitCloud/Components/SystemEnvironment/include/: sysEventsHandler.h dbg.h sysTaskManager.h sysQueue.h sysDuplicateTable.h sysIdleHandler.h sysSleep.h sysEvents.h sysUtils.h sysMutex.h sysTimer.h sysStat.h sysIncrementMacro.h sysDbg.h sysAssert.h sysRepeatMacro.h sysTypes.h sysInit.h sysEndian.h
  group Components/OFD/src
    ../../../BitCloud/Components/HAL/drivers/OFD/src/: ofdCommand.c ofdM25Driver.c ofdAt45dbDriver.c ofdMx25v4006eDriver.c ofdMx25l2006eDriver.c ofdSpiSerializer.c ofdFakeDriver.c ofdIntFlashRead.s90 ofdCrcService.c ofdAt25Driver.c
  group Components/ZCL/src
    ../../../BitCloud/Components/ZCL/src/: zclKeyEstablishmentCluster.c zclOtauClientPdt.c zclSecurityManager.c zclParser.c zclOtauClientDownload.c zclOtauManager.c zclOtauClientQuery.c zclOtauClientDiscovery.c zclCommandAnalyzer.c zclOtauClientUpgrade.c zclOtauClient.c zclTaskManager.c zclAttributes.c zcl.c zclMemoryManager.c zclOtauServer.c
  group Components/ZCL/include
    ../../../BitCloud/Components/ZCL/include/: zclThermostatUiConfCluster.h zclTaskManager.h zclThermostatCluster.h zclPriceCluster.h zclOccupancySensingCluster.h zclInt.h zclIlluminanceMeasurementCluster.h zclHumidityMeasurementCluster.h zclFanControlCluster.h zclAttributes.h zclIdentifyCluster.h zclMessagingCluster.h zclKeyEstablishmentCluster.h zcl.h zclSecurityManager.h zclSmartEnergyTunnelCluster.h zclScenesCluster.h zclOtauManager.h zclBasicCluster.h zclAlarmsCluster.h zclBACnetProtocolTunnelCluster.h zclOnOffSwitchConfigurationCluster.h clusters.h eccAux.h zclOnOffCluster.h genericEcc.h zclIasZoneCluster.h zclLevelControlCluster.h zclIasACECluster.h zclOTAUCluster.h zclOtauClient.h zclDiagnosticsCluster.h zclTemperatureMeasurementCluster.h zclCommandAnalyzer.h zclTimeCluster.h zclGroupsCluster.h zclSimpleMeteringCluster.h zclDemandResponseCluster.h zclPowerConfigurationCluster.h zclGenerictunnelCluster.h zclParser.h zclMemoryManager.h zclMem.h
  group Components/BSP/src
    ../../../BitCloud/Components/BSP/MEGARF/src/: xyl2rgb.c bspVoltageSensor.c bspTaskManager.c bspTempSensor.c hs2xy.c buttons.c MaxL.c lcd.c bspUid.c leds.c fakeBSP.c
  group Components/BSP/include
    ../../../BitCloud/Components/BSP/MEGARF/include/: lcdExt.h bspTaskManager.h hs2xy.h ledsExt.h bspTempSensor.h bspLeds.h buttonsExt.h xyl2rgb.h bspDbg.h maxL.h bspVoltageSensor.h
  group Components/USBFIFO/src
    ../../../BitCloud/Components/HAL/drivers/USBFIFO/src/: usbFifoVirtualUsart.c usbFifoFT245RL.c
  group Components/ConfigServer/src
    ../../../BitCloud/Components/ConfigServer/src/: csPersistentMem.c csMem.c configServer.c
  group Components/ConfigServer/include
    ../../../BitCloud/Components/ConfigServer/include/: csDefaults.h configServer.h
  group Components/ConfigServer/include/private
    ../../../BitCloud/Components/ConfigServer/include/private/: csConstTable.h csBuffers.h csMemTable.h csVarTable.h csSIB.h csDbg.h
  group Components/ISD/src
    ../../../BitCloud/Components/HAL/drivers/ISD/src/: isdImageStorage.c isdConsoleTunneling.c
  group configuration
    ../: configuration.h
