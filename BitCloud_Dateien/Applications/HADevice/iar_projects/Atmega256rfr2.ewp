# IAR project Atmega256rfr2.ewp, settings and files
configuration All_StdlinkSec_MegaRf_Atmega256rfr2_8Mhz (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA256RFR2; STACK_TYPE_ALL; STDLINK_SECURITY_MODE; HAL_8MHz
  ICCAVR.CCDiagSuppress: Pa050, Pe188
  ICCAVR.newCCIncludePaths: ..; ../dimmableLight/include; ../dimmerSwitch/include; ../multiSensor/include; ../thermostat/include; ../ias_ace/include; ../combinedInterface/include; ../common/include; ../common/clusters/include; ../../../BitCloud/Components/BSP/MEGARF/include; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/std/include; ../../../BitCloud/Components/PersistDataServer/wl/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Types/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Util/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Timer/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Task/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_ErrH/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Log/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Memory/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Init/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/src; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/USBFIFO/include; ../../../BitCloud/Components/HAL/avr/atmega128rfa1/common/include; ../../../BitCloud/Components/ZCL/include/private; ../../../BitCloud/Components/ZCL/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/OFD/include; ../../../BitCloud/Components/HAL/drivers/ISD/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/OFD/include; ../../../BitCloud/Components/HAL/drivers/ISD/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/MAC_HWD/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/MACHWD_ZGP/include
  ICCAVR.PreInclude: MakerulesBc_All_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.h
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_All_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega256rfr2_8Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega256rfr2_Iar.o
configuration All_StdlinkSec_MegaRf_Atmega256rfr2_16Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; ATMEGA256RFR2; STACK_TYPE_ALL; STDLINK_SECURITY_MODE; HAL_16MHz
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_All_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega256rfr2_16Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega256rfr2_Iar.o
  group DimmableLight/src
    ../dimmableLight/src/: dlIdentifyCluster.c dlScenes.c dlScenesCluster.c dlPdt.c dlLevelControlCluster.c dlClusters.c dlOnOffCluster.c dimmableLight.c dlGroupsCluster.c dlConsole.c dlBasicCluster.c
  group DimmableLight/include
    ../dimmableLight/include/: dlClusters.h dlGroupsCluster.h dlIdentifyCluster.h dlScenesCluster.h dlScenes.h dlBasicCluster.h dlLevelControlCluster.h dlOnOffCluster.h
  group thermostat/src
    ../thermostat/src/: thGroupsCluster.c thFanControlCluster.c thTimeCluster.c thHumidityMeasurementCluster.c thThermostatCluster.c thOccupancySensingCluster.c thIdentifyCluster.c thPdt.c thDiagnosticsCluster.c thTemperatureMeasurementCluster.c thBasicCluster.c thClusters.c thConsole.c thermostat.c thScenesCluster.c thScenes.c thThermostatUiConfCluster.c thAlarmsCluster.c
  group thermostat/include
    ../thermostat/include/: thDiagnosticsCluster.h thClusters.h thHumidityMeasurementCluster.h thAlarmsCluster.h thGroupsCluster.h thOccupancySensingCluster.h thTemperatureMeasurementCluster.h thTimeCluster.h thIdentifyCluster.h thScenes.h thBasicCluster.h thThermostatUiConfCluster.h thScenesCluster.h thFanControlCluster.h thThermostatCluster.h
  group DimmerSwitch/src
    ../dimmerSwitch/src/: dsLevelControlCluster.c dsIdentifyCluster.c dsOnOffCluster.c dimmerSwitch.c dsConsole.c dsPowerConfigurationCluster.c dsBasicCluster.c dsClusters.c dsAlarmsCluster.c
  group DimmerSwitch/include
    ../dimmerSwitch/include/: dsBasicCluster.h dsIdentifyCluster.h dsAlarmsCluster.h dsOnOffCluster.h dsClusters.h dsLevelControlCluster.h dsPowerConfigurationCluster.h
  group MultiSensor/src
    ../multiSensor/src/: msPdt.c msTemperatureMeasurementCluster.c msDiagnosticsCluster.c msBasicCluster.c msHumidityMeasurementCluster.c msClusters.c msConsole.c msGroupsCluster.c msIdentifyCluster.c msIlluminanceMeasurementCluster.c msOccupancySensingCluster.c multiSensor.c
  group MultiSensor/include
    ../multiSensor/include/: msDiagnosticsCluster.h msOccupancySensingCluster.h msHumidityMeasurementCluster.h msClusters.h msTemperatureMeasurementCluster.h msIdentifyCluster.h msBasicCluster.h msIlluminanceMeasurementCluster.h msGroupsCluster.h
  group CombinedInterface/src
    ../combinedInterface/src/: ciThermostatCluster.c ciIlluminanceMeasurementCluster.c ciGroupsCluster.c ciBasicCluster.c ciOccupancySensingCluster.c ciIdentifyCluster.c ciClusters.c ciTemperatureMeasurementCluster.c ciLevelControlCluster.c ciThermostatUiConfCluster.c ciIasACECluster.c ciHumidityMeasurementCluster.c ciTimeCluster.c combinedInterface.c ciDiagnosticsCluster.c ciAlarmsCluster.c ciPowerConfigurationCluster.c ciFanControlCluster.c ciIasZoneCluster.c ciConsole.c ciOnOffCluster.c ciScenesCluster.c
  group CombinedInterface/include
    ../combinedInterface/include/: ciLevelControlCluster.h ciTemperatureMeasurementCluster.h ciIasZoneCluster.h ciOnOffCluster.h ciHumidityMeasurementCluster.h ciIlluminanceMeasurementCluster.h ciClusters.h ciAlarmsCluster.h ciDiagnosticsCluster.h ciOccupancySensingCluster.h ciThermostatUiConfCluster.h ciFanControlCluster.h ciThermostatCluster.h ciPowerConfigurationCluster.h ciIasACECluster.h ciScenesCluster.h ciTimeCluster.h ciGroupsCluster.h ciBasicCluster.h ciIdentifyCluster.h
  group common/src
    ../common/src/: commandManager.c console.c keyboardPoll.c uartManager.c otauService.c ezModeManager.c zclDevice.c
  group common/include
    ../common/include/: commandManager.h zclDevice.h uartManager.h console.h otauService.h ezModeManager.h appConsts.h
  group common/clusters/src
    ../common/clusters/src/: haClusters.c
  group common/clusters/include
    ../common/clusters/include/: haClusters.h identifyCluster.h basicCluster.h
  group Components/PersistDataServer/std/src
    ../../../BitCloud/Components/PersistDataServer/std/src/: stdPdsMemAccess.c stdPdsTimer.c stdPdsMem.c stdPdsWriteData.c stdPdsCrcService.c stdPdsInit.c stdPdsEvents.c stdPdsDataServer.c
  group Components/PersistDataServer/std/include
    ../../../BitCloud/Components/PersistDataServer/std/include/: stdPdsDbg.h stdPdsFiles.h stdPdsWriteData.h stdPdsTimer.h stdPdsMemAccess.h stdPdsMemAbstract.h stdPdsCrcService.h stdPdsMem.h stdPdsMemIds.h
  group Components/PersistDataServer/src
    ../../../BitCloud/Components/PersistDataServer/src/: fakePds.c
  group Components/PersistDataServer/include
    ../../../BitCloud/Components/PersistDataServer/include/: pdsDataServer.h pdsMemIds.h
  group Components/PersistDataServer/wl/src
    ../../../BitCloud/Components/PersistDataServer/wl/src/: wlPdsDataServer.c wlPdsSecurity.c wlPdsTaskManager.c wlPdsInit.c wlPdsTypesConverter.c
  group Components/PersistDataServer/wl/nv_components/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/src/: S_Nv-SamR21.c S_Nv-ATmega.c S_Nv-External.c S_Nv_Stub.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src/: S_XNv.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/src/: D_Nv.c
  group Components/PersistDataServer/wl/nv_components/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include/: S_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include/: D_XNv_Init.h D_XNv_Bindings.h D_XNv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include/: D_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include/: S_XNv_Bindings.h
  group Components/PersistDataServer/wl/include
    ../../../BitCloud/Components/PersistDataServer/wl/include/: wlPdsBindings.h wlPdsSecurity.h wlPdsMemIds.h wlPdsTypesConverter.h wlPdsTaskManager.h wlPdsTypes.h
  group Components/SystemEnvironment/src
    ../../../BitCloud/Components/SystemEnvironment/src/: sysIdleHandler.c sysSleep.c sysStat.c sysEventsHandler.c sysQueue.c sysUtils.c sysAssert.c sysDuplicateTable.c sysInit.c sysTaskManager.c dbg.c sysMutex.c sysTimer.c
  group Components/SystemEnvironment/include
    ../../../BitCloud/Components/SystemEnvironment/include/: sysEventsHandler.h dbg.h sysTaskManager.h sysQueue.h sysDuplicateTable.h sysIdleHandler.h sysSleep.h sysEvents.h sysUtils.h sysMutex.h sysTimer.h sysStat.h sysIncrementMacro.h sysDbg.h sysAssert.h sysRepeatMacro.h sysTypes.h sysInit.h sysEndian.h
  group Components/OFD/src
    ../../../BitCloud/Components/HAL/drivers/OFD/src/: ofdCommand.c ofdM25Driver.c ofdAt45dbDriver.c ofdMx25v4006eDriver.c ofdMx25l2006eDriver.c ofdSpiSerializer.c ofdFakeDriver.c ofdIntFlashRead.s90 ofdCrcService.c ofdAt25Driver.c
  group Components/ZCL/src
    ../../../BitCloud/Components/ZCL/src/: zclKeyEstablishmentCluster.c zclOtauClientPdt.c zclSecurityManager.c zclParser.c zclOtauClientDownload.c zclOtauManager.c zclOtauClientQuery.c zclMemoryManager.c zclCommandAnalyzer.c zclOtauClientUpgrade.c zclOtauClient.c zclTaskManager.c zclAttributes.c zcl.c zclOtauClientDiscovery.c zclOtauServer.c
  group Components/ZCL/include
    ../../../BitCloud/Components/ZCL/include/: zclThermostatUiConfCluster.h zclTaskManager.h zclThermostatCluster.h zclPriceCluster.h zclOccupancySensingCluster.h zclInt.h zclIlluminanceMeasurementCluster.h zclHumidityMeasurementCluster.h zclFanControlCluster.h zclAttributes.h zclIdentifyCluster.h zclMessagingCluster.h zclKeyEstablishmentCluster.h zcl.h zclSecurityManager.h zclSmartEnergyTunnelCluster.h zclScenesCluster.h zclOtauManager.h zclBasicCluster.h zclAlarmsCluster.h zclBACnetProtocolTunnelCluster.h zclOnOffSwitchConfigurationCluster.h clusters.h eccAux.h zclOnOffCluster.h genericEcc.h zclIasZoneCluster.h zclLevelControlCluster.h zclIasACECluster.h zclOTAUCluster.h zclOtauClient.h zclDiagnosticsCluster.h zclTemperatureMeasurementCluster.h zclCommandAnalyzer.h zclTimeCluster.h zclGroupsCluster.h zclSimpleMeteringCluster.h zclDemandResponseCluster.h zclPowerConfigurationCluster.h zclGenerictunnelCluster.h zclParser.h zclMemoryManager.h zclMem.h
  group Components/BSP/src
    ../../../BitCloud/Components/BSP/MEGARF/src/: xyl2rgb.c bspVoltageSensor.c bspTaskManager.c bspTempSensor.c hs2xy.c buttons.c MaxL.c lcd.c bspUid.c leds.c fakeBSP.c
  group Components/BSP/include
    ../../../BitCloud/Components/BSP/MEGARF/include/: lcdExt.h bspTaskManager.h hs2xy.h ledsExt.h bspTempSensor.h bspLeds.h buttonsExt.h xyl2rgb.h bspDbg.h maxL.h bspVoltageSensor.h
  group Components/USBFIFO/src
    ../../../BitCloud/Components/HAL/drivers/USBFIFO/src/: usbFifoVirtualUsart.c usbFifoFT245RL.c
  group Components/ConfigServer/src
    ../../../BitCloud/Components/ConfigServer/src/: csPersistentMem.c csMem.c configServer.c
  group Components/ConfigServer/include
    ../../../BitCloud/Components/ConfigServer/include/: csDefaults.h configServer.h
  group Components/ConfigServer/include/private
    ../../../BitCloud/Components/ConfigServer/include/private/: csConstTable.h csBuffers.h csMemTable.h csVarTable.h csSIB.h csDbg.h
  group Components/ISD/src
    ../../../BitCloud/Components/HAL/drivers/ISD/src/: isdImageStorage.c isdConsoleTunneling.c
  group ias_ace/src
    ../ias_ace/src/: iasACEIdentifyCluster.c iasACE.c iasACEPdt.c iasACECluster.c iasACEConsole.c iasACEZoneCluster.c iasACEDiagnosticsCluster.c iasACEBasicCluster.c
  group ias_ace/include
    ../ias_ace/include/: iasACEIdentifyCluster.h iasACEDiagnosticsCluster.h iasACECluster.h iasACEBasicCluster.h iasACEZoneCluster.h
  group configuration
    ../: configuration.h
