# IAR project ATmega256RFR2.ewp, settings and files
configuration All_StdlinkSec_MegaRf_Atmega256rfr2_8Mhz (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: BOARD_MEGARF; __ATMEL_BITCLOUD__; ATMEGA256RFR2; STDLINK_SECURITY_MODE; HAL_8MHz; STACK_TYPE_ALL
  ICCAVR.CCDiagSuppress: Pa050, Pe188
  ICCAVR.newCCIncludePaths: ..; ../common/include; ../Light/include; ../ColorSceneRemote/include; ../Bridge/include; ../../../BitCloud/Components/ZLLPlatform; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_AddressManager/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Beacon/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Binding/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Cmi/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Connection/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_DeviceInfo/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_InterPan/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_LinkInitiator/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_LinkTarget/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Radio/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Security/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Zdp/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Zcl_Framework/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_EndDeviceRobustness/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/N_ReconnectHandler/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Address/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Beacon/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_ErrH/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Fsm/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Log/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Memory/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Task/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Timer/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Types/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Util/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Init/include; ../../../BitCloud/Components/Security/SoftAes; ../../../BitCloud/Components/BSP/MEGARF/include; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ZCL/include/private; ../../../BitCloud/Components/ZCL/include; ../../../BitCloud/Components/ZCL/include/private; ../../../BitCloud/Components/ZCL/ZLL/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/DPWM/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/USBFIFO/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/std/include; ../../../BitCloud/Components/PersistDataServer/wl/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Types/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Util/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Timer/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Task/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_ErrH/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Log/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Memory/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Init/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/src; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/OFD/include; ../../../BitCloud/Components/HAL/drivers/ISD/include; ../../../BitCloud/Components/HAL/avr/atmega128rfa1/common/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/MAC_HWD/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/MACHWD_ZGP/include
  ICCAVR.PreInclude: MakerulesBc_All_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.h
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_All_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega256rfr2_8Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega256rfr2_Iar.o
configuration Router_StdlinkSec_MegaRf_Atmega256rfr2_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; __ATMEL_BITCLOUD__; ATMEGA256RFR2; STDLINK_SECURITY_MODE; HAL_8MHz; STACK_TYPE_ROUTER
  ICCAVR.PreInclude: MakerulesBc_Router_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_Router_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega256rfr2_8Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega256rfr2_Iar.o
configuration EndDevice_StdlinkSec_MegaRf_Atmega256rfr2_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; __ATMEL_BITCLOUD__; ATMEGA256RFR2; STDLINK_SECURITY_MODE; HAL_8MHz; STACK_TYPE_ENDDEVICE
  ICCAVR.PreInclude: MakerulesBc_EndDevice_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_EndDevice_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega256rfr2_8Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega256rfr2_Iar.o
configuration All_StdlinkSec_MegaRf_Atmega256rfr2_16Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; __ATMEL_BITCLOUD__; ATMEGA256RFR2; STDLINK_SECURITY_MODE; HAL_16MHz; STACK_TYPE_ALL
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_All_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega256rfr2_16Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega256rfr2_Iar.o
configuration Router_StdlinkSec_MegaRf_Atmega256rfr2_16Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; __ATMEL_BITCLOUD__; ATMEGA256RFR2; STDLINK_SECURITY_MODE; HAL_16MHz; STACK_TYPE_ROUTER
  ICCAVR.PreInclude: as above
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_Router_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega256rfr2_16Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega256rfr2_Iar.o
configuration EndDevice_StdlinkSec_MegaRf_Atmega256rfr2_16Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_MEGARF; __ATMEL_BITCLOUD__; ATMEGA256RFR2; STDLINK_SECURITY_MODE; HAL_16MHz; STACK_TYPE_ENDDEVICE
  ICCAVR.PreInclude: as above
  XLINK.XExtraOptions: -f ../linkerScr/lnkm256rfr2s.xcl; ../../../BitCloud/lib/libBc_EndDevice_StdlinkSec_Atmega256rfr2_Atmega256rfr2_Iar.a; ../../../BitCloud/lib/libHAL_MegaRf_Atmega256rfr2_16Mhz_Iar.a; ../../../BitCloud/lib/WdtInitatmega256rfr2_Iar.o
  group Bridge/src
    ../Bridge/src/: bridgeIdentifyCluster.c bridgeLightsDiscovery.c bridgeClusters.c bridgeCommissioningCluster.c bridgeGroupsCluster.c bridgeLevelControlCluster.c bridgeLinkInfoCluster.c bridge.c bridgeBasicCluster.c bridgeScenesCluster.c bridgeColorControlCluster.c bridgeConsole.c bridgeOnOffCluster.c bridgeOtaCluster.c
  group Bridge/include
    ../Bridge/include/: bridgeIdentifyCluster.h bridgeLinkInfoCluster.h bridgeScenesCluster.h bridgeOnOffCluster.h bridgeBindings.h bridgeColorControlCluster.h bridgeClusters.h bridgeLevelControlCluster.h bridgeOtaCluster.h bridgeGroupsCluster.h bridgeBasicCluster.h bridgeLightsDiscovery.h bridgeCommissioningCluster.h
  group Light/src
    ../Light/src/: LightScenesCluster.c LightOnOffCluster.c Light.c LightCommissioningCluster.c LightColorSchemesConversion.c LightTesting.c LightIdentifyCluster.c LightPdt.c LightClusters.c lightOtaCluster.c LightBasicCluster.c LightGroupsCluster.c LightConsole.c LightColorControlCluster.c LightLevelControlCluster.c
  group Light/include
    ../Light/include/: lightOtaCluster.h LightGroupsCluster.h LightLevelControlCluster.h LightIdentifyCluster.h LightCommissioningCluster.h LightTesting.h LightOnOffCluster.h LightColorControlCluster.h LightScenesCluster.h LightClusters.h LightBasicCluster.h LightColorSchemesConversion.h
  group ColorSceneRemote/src
    ../ColorSceneRemote/src/: colorSceneRemoteTesting.c colorSceneRemoteOtaCluster.c colorSceneRemoteCommissioningCluster.c buttonHandlers.c colorSceneRemoteColorControlCluster.c colorSceneRemoteFsm.c colorSceneRemoteClusters.c colorSceneRemoteOnOffCluster.c colorSceneRemoteGroupsCluster.c colorSceneRemoteLevelControlCluster.c colorSceneRemotePdt.c colorSceneRemoteScenesCluster.c colorSceneRemoteLinkInfoCluster.c colorSceneRemote.c colorSceneRemoteBasicCluster.c colorSceneRemoteConsole.c colorSceneRemoteIdentifyCluster.c
  group ColorSceneRemote/include
    ../ColorSceneRemote/include/: colorSceneRemoteScenesCluster.h colorSceneRemoteGroupsCluster.h colorSceneRemoteOtaCluster.h colorSceneRemoteTesting.h colorSceneRemoteIdentifyCluster.h colorSceneRemoteLevelControlCluster.h colorSceneRemoteBasicCluster.h colorSceneRemoteColorControlCluster.h colorSceneRemoteCommissioningCluster.h colorSceneRemoteLinkInfoCluster.h colorSceneRemoteClusters.h colorSceneRemoteOnOffCluster.h colorSceneRemoteConsole.h colorSceneRemoteFsm.h
  group common/src
    ../common/src/: commandManager.c console.c uartManager.c N_PacketDistributor.c errH.c debug.c networkJoining.c
  group common/include
    ../common/include/: commandManager.h errH.h N_PacketDistributor.h N_ZllEndpoint.h uartManager.h zllDemo.h otauService.h debug.h console.h networkJoining.h
  group Components/PersistDataServer/std/src
    ../../../BitCloud/Components/PersistDataServer/std/src/: stdPdsMemAccess.c stdPdsTimer.c stdPdsMem.c stdPdsWriteData.c stdPdsCrcService.c stdPdsInit.c stdPdsEvents.c stdPdsDataServer.c
  group Components/PersistDataServer/std/include
    ../../../BitCloud/Components/PersistDataServer/std/include/: stdPdsDbg.h stdPdsFiles.h stdPdsWriteData.h stdPdsTimer.h stdPdsMemAccess.h stdPdsMemAbstract.h stdPdsCrcService.h stdPdsMem.h stdPdsMemIds.h
  group Components/PersistDataServer/src
    ../../../BitCloud/Components/PersistDataServer/src/: fakePds.c
  group Components/PersistDataServer/include
    ../../../BitCloud/Components/PersistDataServer/include/: pdsDataServer.h pdsMemIds.h
  group Components/PersistDataServer/wl/src
    ../../../BitCloud/Components/PersistDataServer/wl/src/: wlPdsTypesConverter.c wlPdsDataServer.c wlPdsSecurity.c wlPdsInit.c wlPdsTaskManager.c
  group Components/PersistDataServer/wl/nv_components/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/src/: S_Nv-SamR21.c S_Nv-ATmega.c S_Nv-External.c S_Nv_Stub.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src/: S_XNv.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/src/: D_Nv.c
  group Components/PersistDataServer/wl/nv_components/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include/: S_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include/: D_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include/: D_XNv_Bindings.h D_XNv_Init.h D_XNv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include/: S_XNv_Bindings.h
  group Components/PersistDataServer/wl/include
    ../../../BitCloud/Components/PersistDataServer/wl/include/: wlPdsSecurity.h wlPdsBindings.h wlPdsMemIds.h wlPdsTypesConverter.h wlPdsTaskManager.h wlPdsTypes.h
  group Components/DPWM/src
    ../../../BitCloud/Components/HAL/drivers/DPWM/src/: dithTimerIsr.c dithPwm.c
  group Components/DPWM/include
    ../../../BitCloud/Components/HAL/drivers/DPWM/include/: dithTimerIsr.h
  group Components/SystemEnvironment/src
    ../../../BitCloud/Components/SystemEnvironment/src/: sysIdleHandler.c sysSleep.c sysStat.c sysEventsHandler.c sysQueue.c sysUtils.c sysAssert.c sysDuplicateTable.c sysInit.c sysTaskManager.c sysTimer.c sysMutex.c dbg.c
  group Components/SystemEnvironment/include
    ../../../BitCloud/Components/SystemEnvironment/include/: sysMutex.h dbg.h sysTaskManager.h sysQueue.h sysDuplicateTable.h sysIdleHandler.h sysSleep.h sysEvents.h sysUtils.h sysEventsHandler.h sysTimer.h sysStat.h sysIncrementMacro.h sysDbg.h sysAssert.h sysRepeatMacro.h sysTypes.h sysInit.h sysEndian.h
  group Components/ZLLPlatform
    ../../../BitCloud/Components/ZLLPlatform/: devconfig.h
  group Components/ZLLPlatform/ZLL/N_Connection/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Connection/src/: N_Connection_ReconnectHandler.c N_ConnectionAssociation.c N_ConnectionCommon.c N_ConnectionEnddevice.c N_ConnectionRouter.c
  group Components/ZLLPlatform/ZLL/N_Connection/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Connection/include/: N_ConnectionRouter_Init.h N_ConnectionEnddevice_Init.h N_Connection_ReconnectHandler.h N_ConnectionRouter_Bindings.h N_Connection_Private.h N_ConnectionEnddevice_Bindings.h N_Connection.h N_Connection_Internal.h
  group Components/ZLLPlatform/ZLL/N_EndDeviceRobustness/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_EndDeviceRobustness/src/: N_EndDeviceRobustness.c
  group Components/ZLLPlatform/ZLL/N_EndDeviceRobustness/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_EndDeviceRobustness/include/: N_EndDeviceRobustness_Init.h N_EndDeviceRobustness.h N_EndDeviceRobustness_Bindings.h
  group Components/ZLLPlatform/ZLL/S_Nv/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include/: S_Nv_Init.h S_Nv_Bindings.h S_NvInternal.h S_Nv_Stack_Ids.h
  group Components/ZLLPlatform/ZLL/N_Cmi/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Cmi/src/: N_Cmi.c
  group Components/ZLLPlatform/ZLL/N_Cmi/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Cmi/include/: N_Cmi_Init.h N_Cmi.h N_Cmi_Bindings.h
  group Components/ZLLPlatform/ZLL/N_InterPan/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_InterPan/src/: N_InterPan.c N_InterPanBuffers.c
  group Components/ZLLPlatform/ZLL/N_InterPan/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_InterPan/include/: N_InterPan_Init.h N_InterPan.h N_InterPan_Bindings.h N_InterPanBuffers.h
  group Components/ZLLPlatform/ZLL/N_Binding/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Binding/src/: N_Binding.c
  group Components/ZLLPlatform/ZLL/N_Binding/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Binding/include/: N_Binding_Init.h N_Binding.h N_Binding_Bindings.h
  group Components/ZLLPlatform/ZLL/N_DeviceInfo/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_DeviceInfo/src/: N_DeviceInfo.c
  group Components/ZLLPlatform/ZLL/N_DeviceInfo/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_DeviceInfo/include/: N_DeviceInfo_Bindings.h N_DeviceInfo.h N_DeviceInfo_Init.h N_DeviceInfo_Version.h
  group Components/ZLLPlatform/ZLL/N_Radio/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Radio/src/: N_Radio.c
  group Components/ZLLPlatform/ZLL/N_Radio/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Radio/include/: N_Radio_Init.h N_Radio_Internal.h N_Radio.h N_Radio_Bindings.h
  group Components/ZLLPlatform/ZLL/N_Beacon/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Beacon/include/: N_Beacon.h
  group Components/ZLLPlatform/ZLL/N_Zdp/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Zdp/src/: N_Zdp.c
  group Components/ZLLPlatform/ZLL/N_Zdp/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Zdp/include/: N_Zdp.h N_Zdp_Init.h
  group Components/ZLLPlatform/ZLL/N_Zcl_Framework/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Zcl_Framework/include/: N_Zcl_Framework.h N_Zcl_Framework_Bindings.h N_Zcl_DataInd.h
  group Components/ZLLPlatform/ZLL/N_Security/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Security/src/: N_Security_Calc.c N_Security.c
  group Components/ZLLPlatform/ZLL/N_Security/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_Security/include/: N_Security.h N_Security_Calc.h N_Security_Init.h
  group Components/ZLLPlatform/ZLL/N_ReconnectHandler/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_ReconnectHandler/src/: N_ReconnectHandler.c
  group Components/ZLLPlatform/ZLL/N_ReconnectHandler/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_ReconnectHandler/include/: N_ReconnectHandler.h N_ReconnectHandler_Bindings.h N_ReconnectHandler_Init.h
  group Components/ZLLPlatform/ZLL/N_AddressManager/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_AddressManager/src/: N_AddressManager.c
  group Components/ZLLPlatform/ZLL/N_AddressManager/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_AddressManager/include/: N_AddressManager_Init.h N_AddressManager.h N_AddressManager_Bindings.h
  group Components/ZLLPlatform/ZLL/N_LinkTarget/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_LinkTarget/src/: N_LinkTarget.c
  group Components/ZLLPlatform/ZLL/N_LinkTarget/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_LinkTarget/include/: N_LinkTarget_Init.h N_LinkTarget.h N_LinkTarget_Bindings.h
  group Components/ZLLPlatform/ZLL/N_LinkInitiator/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_LinkInitiator/src/: N_LinkInitiator.c
  group Components/ZLLPlatform/ZLL/N_LinkInitiator/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/N_LinkInitiator/include/: N_LinkInitiator.h N_LinkInitiator_Bindings.h N_LinkInitiator_Init.h
  group Components/ZLLPlatform/Infrastructure/N_Fsm/src
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Fsm/src/: N_Fsm.c
  group Components/ZLLPlatform/Infrastructure/N_Fsm/include
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Fsm/include/: N_Fsm.h
  group Components/ZLLPlatform/Infrastructure/N_Log/src
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Log/src/: N_Log.c
  group Components/ZLLPlatform/Infrastructure/N_Log/include
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Log/include/: N_Log.h
  group Components/ZLLPlatform/Infrastructure/N_Util/src
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Util/src/: N_Util.c
  group Components/ZLLPlatform/Infrastructure/N_Util/include
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Util/include/: N_Util_Bindings.h N_Util.h
  group Components/ZLLPlatform/Infrastructure/N_Memory/src
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Memory/src/: N_Memory-Atmel.c
  group Components/ZLLPlatform/Infrastructure/N_Memory/include
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Memory/include/: N_Memory.h
  group Components/ZLLPlatform/Infrastructure/N_Beacon/include
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Beacon/include/: N_Beacon.h
  group Components/ZLLPlatform/Infrastructure/N_Types/include
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Types/include/: N_Types.h
  group Components/ZLLPlatform/Infrastructure/N_Task/src
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Task/src/: N_Task-Internal-Atmel.c N_Task.c
  group Components/ZLLPlatform/Infrastructure/N_Task/include
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Task/include/: N_Task_Init.h N_Task_Bindings.h N_Task.h N_Task-Internal.h
  group Components/ZLLPlatform/Infrastructure/N_Init/include
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Init/include/: N_Init.h
  group Components/ZLLPlatform/Infrastructure/N_Address/src
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Address/src/: N_Address.c
  group Components/ZLLPlatform/Infrastructure/N_Address/include
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Address/include/: N_Address.h
  group Components/ZLLPlatform/Infrastructure/N_Timer/src
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Timer/src/: N_Timer-Internal-Atmel.c N_Timer.c
  group Components/ZLLPlatform/Infrastructure/N_Timer/include
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Timer/include/: N_Timer.h N_Timer_Init.h N_Timer_Bindings.h N_Timer-Internal.h
  group Components/ZLLPlatform/Infrastructure/N_ErrH/src
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_ErrH/src/: N_ErrH.c
  group Components/ZLLPlatform/Infrastructure/N_ErrH/include
    ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_ErrH/include/: N_ErrH.h
  group Components/OFD/src
    ../../../BitCloud/Components/HAL/drivers/OFD/src/: ofdCommand.c ofdM25Driver.c ofdAt45dbDriver.c ofdFakeDriver.c ofdMx25l2006eDriver.c ofdSpiSerializer.c ofdMx25v4006eDriver.c ofdIntFlashRead.s90 ofdCrcService.c ofdAt25Driver.c
  group Components/ZCL/src
    ../../../BitCloud/Components/ZCL/src/: zclOtauClientDiscovery.c zclOtauClientPdt.c zclSecurityManager.c zclParser.c zclOtauClientDownload.c zclTaskManager.c zclOtauClientQuery.c zclMemoryManager.c zclCommandAnalyzer.c zclOtauClientUpgrade.c zclOtauClient.c zclOtauManager.c zclAttributes.c zcl.c zclKeyEstablishmentCluster.c zclOtauServer.c
  group Components/ZCL/include
    ../../../BitCloud/Components/ZCL/include/: zclThermostatUiConfCluster.h zclTaskManager.h zclThermostatCluster.h zclCommandAnalyzer.h zclPriceCluster.h zclOccupancySensingCluster.h zclZllCommissioningCluster.h zclTimeCluster.h zclIlluminanceMeasurementCluster.h zclHumidityMeasurementCluster.h zclFanControlCluster.h zclAttributes.h zclIdentifyCluster.h zclMessagingCluster.h zclKeyEstablishmentCluster.h zclSecurityManager.h zclZllBasicCluster.h zclSmartEnergyTunnelCluster.h zclScenesCluster.h zclZllIdentifyCluster.h zclZllLevelControlCluster.h zclZllOnOffCluster.h zclBasicCluster.h zclIasACECluster.h zclOtauManager.h zclZllScenesCluster.h zclBACnetProtocolTunnelCluster.h zclOnOffSwitchConfigurationCluster.h eccAux.h clusters.h zclOnOffCluster.h genericEcc.h zclIasZoneCluster.h zclLevelControlCluster.h zclAlarmsCluster.h zclOTAUCluster.h zclOtauClient.h zclDiagnosticsCluster.h zclTemperatureMeasurementCluster.h zcl.h zclInt.h zclGroupsCluster.h zclSimpleMeteringCluster.h zclDemandResponseCluster.h zclPowerConfigurationCluster.h zclGenerictunnelCluster.h zclZllColorControlCluster.h zclZllGroupsCluster.h zclParser.h zclMemoryManager.h zclMem.h
  group Components/BSP/src
    ../../../BitCloud/Components/BSP/MEGARF/src/: xyl2rgb.c bspVoltageSensor.c bspTaskManager.c bspTempSensor.c hs2xy.c buttons.c MaxL.c lcd.c bspUid.c leds.c fakeBSP.c
  group Components/BSP/include
    ../../../BitCloud/Components/BSP/MEGARF/include/: maxL.h lcdExt.h bspTaskManager.h hs2xy.h ledsExt.h bspTempSensor.h bspLeds.h buttonsExt.h xyl2rgb.h bspDbg.h bspVoltageSensor.h
  group Components/USBFIFO/src
    ../../../BitCloud/Components/HAL/drivers/USBFIFO/src/: usbFifoVirtualUsart.c usbFifoFT245RL.c
  group Components/ISD/src
    ../../../BitCloud/Components/HAL/drivers/ISD/src/: isdImageStorage.c isdConsoleTunneling.c
  group Components/ConfigServer/src
    ../../../BitCloud/Components/ConfigServer/src/: csPersistentMem.c csMem.c configServer.c
  group Components/ConfigServer/include
    ../../../BitCloud/Components/ConfigServer/include/: csDefaults.h configServer.h
  group Components/ConfigServer/include/private
    ../../../BitCloud/Components/ConfigServer/include/private/: csConstTable.h csBuffers.h csVarTable.h csMemTable.h csSIB.h csDbg.h
  group configuration
    ../: configuration.h
